File: Booth/Booth.kicad_pcb (KiCad board)
At the start: 2 copper layers, 5.1 x 5.1 mm, 6 parts, among them J101 -, J102 +

Commit message: Upgrade Kicad version.
Other:
- net class Default removed
